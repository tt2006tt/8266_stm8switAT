# IAR project Backup of STM8S_BootLoader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208RB STM8S208RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\USER\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S_BootLoader.bin
  ILINK.IlinkOutputFile: STM8S_BootLoader.out
  ILINK.IlinkIcfFile: ..\Project\settings\lnkstm8s208rb.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWlib/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_uart1.c
  group USER
    ../USER/src/: common.c flash_if.c main.c menu.c stm8s_it.c uart1.c ymodem.c
