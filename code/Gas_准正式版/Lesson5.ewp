# IAR project Lesson5.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Lesson5.bin
  ILINK.IlinkOutputFile: Lesson1.out
  ILINK.IlinkIcfFile: C:\Users\pc\Desktop\8266\code\Gas_准正式版\Linker\STM8S105K6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: Lesson5.out
  group (top)
    APP/: flash.c
  group APP
    APP/: allInclude.h beep.c ESP8826.c key.c led.c main.c MP_4.c stm8s_it.c stm8s_it.h uart.c
    STM8S_StdPeriph_Driver/inc/: Text.h
  group LInker
    Linker/: STM8S105K6.icf
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_conf.h stm8s_flash.h stm8s_gpio.h stm8s_tim2.h stm8s_uart2.h stm8s_wwdg.h
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim2.c stm8s_uart2.c stm8s_wwdg.c
